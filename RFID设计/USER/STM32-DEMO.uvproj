# Keil uVision project STM32-DEMO.uvproj, settings and files
target ucos-c8t6 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO-20181208 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\USER;..\APP;..\BSP;..\uCOS-II\Ports;..\uCOS-II\Source;..\APP\usart;..\BSP\BUJIN;..\BSP\WDG;..\BSP\oled;..\BSP\INA219;..\BSP\INA219;..\BSP\RC522
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c
  group CMSIS
    ../CMSIS/: system_stm32f10x.c
  group BSP
    ../BSP/: BSP.c led.c delay.c ntctemp.c dht11.c
    ../BSP/WDG/: wdg.c
    ../BSP/oled/: oled.c
    ../BSP/RC522/: rc522_config.c rc522_function.c
  group APP
    ../APP/: app.c
    ../APP/usart/: usart.c
  group uCOS-II\Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II\Ports
    ../uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c
